# Keil uVision project first.uvprojx, settings and files
target templateMS (ARM-ADS)
  device: STM32L152RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: templateMS +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MDP
  c include: ..\Project;..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group project
    ./: main.c stm32l1xx_it.c
  group libraries
    ../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group ::Device
    RTE/Device/STM32L152RC/: startup_stm32l1xx_mdp.s system_stm32l1xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
